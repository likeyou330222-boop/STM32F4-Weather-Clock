# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\app;..\driver\led;..\driver\key;..\driver\rtc;..\driver\esp_at;..\driver\console;..\driver\ILI9341;..\driver\aht20;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib\freertos\include;..\third_lib\freertos\portable;..\third_lib;..\third_lib\lvgl;..\driver\LVGL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c app.c board.c weather_UI.c sensor_task.c network_task.c weather_lvgl_ui.c weather_icons.c
  group driver
    ../driver/key/: key.c
    ../driver/led/: led.c
    ../driver/console/: console.c console_log.c
    ../driver/ILI9341/: ili9341_port.c ili9341.c ili9341_freertos.c ili9341_gfx.c ili9341_assets.c font_data.c image_data.c
    ../driver/rtc/: rtc.c
    ../driver/aht20/: aht20.c aht20_port.c
    ../driver/esp_at/: esp_at.c esp_at_port.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freertos
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/freertos/portable/: heap_4.c port.c
  group LVGL_Core
    ../third_lib/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL_HAL
    ../third_lib/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_Misc
    ../third_lib/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_Draw
    ../third_lib/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL_Draw_SW
    ../third_lib/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL_Font
    ../third_lib/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_montserrat_24.c lv_font_montserrat_42.c lv_font_montserrat_48.c
  group LVGL_Widgets
    ../third_lib/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Extra
    ../third_lib/lvgl/src/extra/: lv_extra.c
    ../third_lib/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../third_lib/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_lib/lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group LVGL_Layout
    ../third_lib/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_lib/lvgl/src/extra/layouts/grid/: lv_grid.c
  group LVGL_Port
    ../driver/LVGL/: lvgl_port_disp.c
